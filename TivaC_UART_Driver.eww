<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TivaC_UART_Driver.ewp</path>
    </project>
    <batchBuild />
</workspace>
